# Keil uVision project Keil_Split_Str.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MDR1986BE92 Milandr
  pack: Keil.MDR1986BExx.1.5
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Keil_Split_Str +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.cpp
software components: CMSIS:CORE 5.1.2, Device:Startup 1.5
